# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_PCA10028 S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\config;..\..\..\sdk_components\libraries\bootloader_dfu;..\..\..\sdk_components\libraries\bootloader_dfu\ble_transport;..\..\..\sdk_components\softdevice\s110\headers;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\device;..\..\..\sdk_components\toolchain;..\..\..\sdk_components\libraries\crc16;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\ble\common;..\..\..\sdk_components\libraries\hci;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\drivers_nrf\pstorage;..\..\..\sdk_components\libraries\scheduler
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../: main.c dfu_ble_svc.c
  group nRF_BLE
    ../../../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../../../sdk_components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../../../sdk_components/drivers_nrf/hal/: nrf_delay.c
    ../../../sdk_components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    ../../../sdk_components/libraries/util/: app_error.c nrf_assert.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../../sdk_components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c
    ../../../sdk_components/libraries/crc16/: crc16.c
    ../../../sdk_components/libraries/hci/: hci_mem_pool.c
  group nRF_SoftDevice
    ../../../sdk_components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../../../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group ::Device
    RTE/Device/nRF51422_xxAC/: arm_startup_nrf51.s system_nrf51.c
software components: CMSIS:CORE 3.40.0, Device:Startup 7.2.1
