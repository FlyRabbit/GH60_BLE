# Keil uVision project desktop_keyboard.uvprojx, settings and files
target nRF51822_S110 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: desktop_keyboard_release +hex
  c flags: Optim=4 oTime=1 v6Lang=1 v6LangP=1
  c define: NRF51,SOFTDEVICE_PRESENT,BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\..\..\include;..\..\..\sdk_components\drivers_nrf\pstorage;..\..\..\sdk_components\drivers_nrf\ble_flash;..\..\..\sdk_components\drivers_nrf\hal;..\..\..\sdk_components\libraries\crc16;..\..\..\sdk_components\libraries\scheduler;..\..\..\sdk_components\libraries\bootloader_dfu;..\..\..\sdk_components\libraries\timer;..\..\..\sdk_components\libraries\util;..\..\..\sdk_components\softdevice\s110\headers;..\..\..\sdk_components\softdevice\common\softdevice_handler;..\..\..\sdk_components\ble\common;..\..\..\sdk_components\ble\device_manager;..\..\..\sdk_components\ble\ble_services\ble_bas;..\..\..\sdk_components\ble\ble_services\ble_dis;..\..\..\sdk_components\ble\ble_services\ble_hids;..\..\..\sdk_components\ble\ble_services\ble_dfu;..\..\..\sdk_components\libraries\trace;..\..\..\nrf51_hid_platform\include\RTT;..\..\..\sdk_bsp;..\..\..\sdk_components\libraries\button;..\..\..\sdk_components\drivers_nrf\gpiote;..\..\..\include\config;..\..\..\sdk_components\drivers_nrf\common;..\..\..\include\debug;..\config;..\..\..\sdk_components\properitary_rf\gzll;..\..\..\nrf51_hid_platform\include
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source Code
    ./../: main.c
  group Services
    ../../../sdk_components/ble/ble_services/ble_bas/: ble_bas.c
    ../../../sdk_components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../sdk_components/ble/common/: ble_srv_common.c
    ../../../sdk_components/ble/ble_services/ble_hids/: ble_hids.c
    ../../../sdk_components/ble/ble_services/ble_dfu/: ble_dfu.c
  group Libraries
    ../../../sdk_components/ble/common/: ble_advdata.c ble_conn_params.c
    ../../../sdk_components/drivers_nrf/ble_flash/: ble_flash.c
    ../../../sdk_components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../sdk_components/libraries/scheduler/: app_scheduler.c
    ../../../sdk_components/libraries/timer/: app_timer_appsh.c app_timer.c
    ../../../sdk_components/drivers_nrf/hal/: nrf_nvmc.c nrf_delay.c
    ../../../sdk_components/libraries/crc16/: crc16.c
    ../../../sdk_components/drivers_nrf/pstorage/: pstorage.c
    ../../../sdk_components/ble/device_manager/: device_manager_peripheral.c
    ../../../sdk_components/libraries/bootloader_dfu/: bootloader_util.c dfu_app_handler.c
    ../../../sdk_components/libraries/util/: nrf_assert.c
    ../../../sdk_components/drivers_nrf/common/: nrf_drv_common.c
  group modules
    ../../../nrf51_hid_platform/source/: m_coms.c m_coms_ble.c m_coms_ble_addr.c m_coms_ble_adv.c m_coms_ble_hid.c m_batt_meas.c m_pwr_and_clk_mgmt.c
    ../../../source/: m_keyboard.c
  group drivers
    ../../../source/: drv_keyboard_cherry8x16.c
  group hal
    ../../../nrf51_hid_platform/source/: hal_adc.c
    ../../../source/: hal_rng.c hal_gpiote.c
software components: CMSIS:CORE 4.1.0, Device:Startup 8.0.0
